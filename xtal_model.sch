** sch_path: xtal_model.sch
**.subckt xtal_model XO2 XO1
*.iopin XO2
*.iopin XO1
R1 XO1 net1 1k m=1
Cm net1 net2 1p m=1
C0 XO1 XO2 1p m=1
Lm net2 XO2 1n m=1
**.ends
.end
