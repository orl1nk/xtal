** sch_path: xtal_model.sch
**.subckt xtal_model
R1 net2 net1 1k m=1
Cm net1 net3 1p m=1
C0 net2 net4 1p m=1
Lm net3 net4 1n m=1
**.ends
.end
